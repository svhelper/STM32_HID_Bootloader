# Keil uVision project f1.uvprojx, settings and files
target hid_bootloader (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.3.0
  cpu: IRAM(0x20000000,0x00005000) IROM(0x08000000,0x00010000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: hid_bootloader
  group Source
    ./Src/: flash.c hid.c led.c main.c usb.c
  group Header
    ./Inc/: config.h flash.h hid.h led.h usb.h
